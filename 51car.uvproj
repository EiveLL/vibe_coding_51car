# Keil uVision project 51car.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: 51car +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c hardware.h rc522.c rc522.h
